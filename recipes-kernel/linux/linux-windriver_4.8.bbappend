require linux-windriver-wrs-sbc8548.inc

