require linux-yocto-wrs-sbc8548.inc
